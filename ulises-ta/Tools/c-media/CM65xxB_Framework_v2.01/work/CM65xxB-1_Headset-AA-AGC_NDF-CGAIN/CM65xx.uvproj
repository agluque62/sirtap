# Keil uVision project CM65xx.uvproj, settings and files
target Target 1 (MCS-51)
  device: R8051XC Evatronix
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: cm65xxfw +hex
  AfterMake: ..\..\Tools\Hex2Rom.exe  .\output\cm65xxfw.hex .\output\Cm65xxB-1_ROM.bin
  c flags: Optimize=9
  c include: ..\..\CM65xxB-1\inc;.\inc
  asm include: ..\..\CM65xxB-1\inc;.\inc
  group Source Group 1
    ./: usb.c audio.c int.c io.c main.c request.c dscr.a51 STARTUP.A51
    ../../CM65xxB-1/: CM65xxB-1.LIB
